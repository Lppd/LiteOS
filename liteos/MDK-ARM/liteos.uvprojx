# Keil uVision project liteos.uvprojx, settings and files
target liteos (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: liteos +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../Core/LiteOS/kernel/arch/include;../Core/LiteOS/kernel/include;../Core/LiteOS/utils;../Core/LiteOS/utils/internal;../Core/LiteOS/components/power;../Core/LiteOS/components/exchook;../Core/LiteOS/kernel/arch/arm/cortex-m3/keil;../Core/utils_native/base/include;../Core/target_config
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  scatter file: ..\litos.sct
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dma.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group LiteOS/arch
    ../Core/LiteOS/kernel/arch/arm/cortex-m3/keil/: los_context.c los_dispatch.S los_exc.S los_interrupt.c los_timer.c
  group LiteOS/kernel
    ../Core/LiteOS/kernel/src/: los_event.c los_init.c los_mux.c los_queue.c los_sched.c los_sem.c los_sortlink.c los_swtmr.c los_task.c los_tick.c
    ../Core/LiteOS/kernel/src/mm/: los_membox.c los_memory.c
  group LieOS/components
    ../Core/LiteOS/components/power/: los_pm.c
    ../Core/LiteOS/components/exchook/: los_exc_info.c los_exchook.c
  group LiteOS/utils_native
    ../Core/utils_native/base/src/securec/: memcpy_s.c memset_s.c strcpy_s.c strncpy_s.c
  group LiteOS/utils
    ../Core/LiteOS/utils/: los_debug.c los_error.c
software components: CMSIS:CORE 4.3.0
